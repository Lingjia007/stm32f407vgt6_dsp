# Keil uVision project stm32f407vgt6_dsp.uvprojx, settings and files
target stm32f407vgt6_dsp (6210000::V6.21::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f407vgt6_dsp +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/PrivateInclude;../DSP_Test
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../DSP_Test/: dsp_test.c dsp_basic_math_test.c dsp_complex_math_test.c dsp_controller_test.c dsp_fast_math_test.c dsp_filtering_test.c dsp_matrix_test.c dsp_statistics_test.c dsp_support_test.c dsp_transform_test.c dsp_bayes_test.c dsp_distance_test.c dsp_interpolation_test.c dsp_quaternion_test.c dsp_svm_test.c
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group DSP/BasicMathFunctions
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
  group DSP/CommonTables
    ../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
  group DSP/ComplexMathFunctions
    ../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
  group DSP/ControllerFunctions
    ../Drivers/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DSP/FastMathFunctions
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
  group DSP/FilteringFunctions
    ../Drivers/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
  group DSP/MatrixFunctions
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
  group DSP/StatisticsFunctions
    ../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
  group DSP/SupportFunctions
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
  group DSP/TransformFunctions
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group DSP/BayesFunctions
    ../Drivers/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
  group DSP/DistanceFunctions
    ../Drivers/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
  group DSP/InterpolationFunctions
    ../Drivers/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
  group DSP/QuaternionMathFunctions
    ../Drivers/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group DSP/SVMFunctions
    ../Drivers/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
software components: CMSIS:CORE 6.1.0
